# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC16F40K128 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x17FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Project +hex
  group ALGORITHSM
    ./CODE/ALGORITHM/: EM_Calc.c EM_Calc.h PID.c PID.h LCD_show.c LCD_show.h
  group Liberies
    ./CODE/Libraries/libraries/: board.c board.h common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h STC_DFP.LIB STC16Fxx.h
    ./CODE/Libraries/seekfree_libraries/: zf_adc.c zf_adc.h zf_delay.c zf_delay.h zf_exti.c zf_exti.h zf_gpio.c zf_gpio.h zf_iic.c zf_iic.h zf_mdu16.c zf_mdu16.h zf_nvic.c zf_nvic.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
    ./CODE/Libraries/seekfree_peripheral/: headfile.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_AT24C02.c SEEKFREE_AT24C02.h SEEKFREE_BLUETOOTH_CH9141.c SEEKFREE_BLUETOOTH_CH9141.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h
  group DRIVER
    ./CODE/DRIVER/: EM_SENSOR.c EM_SENSOR.h ENCODE_SENSOR.c ENCODE_SENSOR.h SERVO_MOTOR.c SERVO_MOTOR.h STEP_MOTOR.h STEP_MOTOR.C
  group USER
    ./CODE/USER/: main.c isr.c isr.h CONTROL_SYSTEM.h SERVO_MOTOR_CONTROL.h STEP_MOTOR_CONTROL.h CONTROL_SYSTEM.c SERVO_MOTOR_CONTROL.C STEP_MOTOR_CONTROL.C
